# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F469xx, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --locale=english
  c include: applications;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;.\rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;board\ports\touch;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\finsh;.;rt-thread\include;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;libraries\STM32F4xx_HAL\CMSIS\Include;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;.\rt-thread\components\net\at\include;.\rt-thread\components\net\at\at_socket;.\rt-thread\components\net\netdev\include;.\rt-thread\components\net\sal\include;.\rt-thread\components\net\sal\include\socket;.\rt-thread\components\net\sal\impl;.\rt-thread\components\net\sal\include\dfs_net;.\rt-thread\components\net\sal\include\socket\sys_socket;packages\webclient-v2.2.0\inc;.\applications\lv_desktop_gui\font;.\applications\lv_desktop_gui\imgs;.\applications\lv_desktop_gui\tests;.\packages\lv_100ask_lib\src\lv_100ask_page_manager;.\packages\lv_100ask_lib;.\packages\lv_100ask_lib\src\lv_100ask_2048;.\packages;.\packages\lv_100ask_lib\test\lv_100ask_page_manager_test;.\packages\LVGL-v8.2.0\examples\assets;.\packages\lv_100ask_lib\test\lv_100ask_2048_test;packages\ez_iot_os-v2.0.0\components\cJSON\inc;..\..\..\components\fal\inc;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\finsh;.;..\..\..\include;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include;packages\LVGL-v8.2.0\src;packages\LVGL-v8.2.0\src\core;packages\LVGL-v8.2.0\src\draw;packages\LVGL-v8.2.0\src\extra;packages\LVGL-v8.2.0\src\font;packages\LVGL-v8.2.0\src\gpu;packages\LVGL-v8.2.0\src\hal;packages\LVGL-v8.2.0\src\misc;packages\LVGL-v8.2.0\src\widgets;packages\LVGL-v8.2.0\src\draw\nxp_pxp;packages\LVGL-v8.2.0\src\draw\nxp_vglite;packages\LVGL-v8.2.0\src\draw\sdl;packages\LVGL-v8.2.0\src\draw\stm32_dma2d;packages\LVGL-v8.2.0\src\draw\sw;packages\LVGL-v8.2.0\src\extra\layouts;packages\LVGL-v8.2.0\src\extra\libs;packages\LVGL-v8.2.0\src\extra\others;packages\LVGL-v8.2.0\src\extra\themes;packages\LVGL-v8.2.0\src\extra\widgets;packages\LVGL-v8.2.0\src\extra\layouts\flex;packages\LVGL-v8.2.0\src\extra\layouts\grid;packages\LVGL-v8.2.0\src\extra\libs\bmp;packages\LVGL-v8.2.0\src\extra\libs\ffmpeg;packages\LVGL-v8.2.0\src\extra\libs\freetype;packages\LVGL-v8.2.0\src\extra\libs\fsdrv;packages\LVGL-v8.2.0\src\extra\libs\gif;packages\LVGL-v8.2.0\src\extra\libs\png;packages\LVGL-v8.2.0\src\extra\libs\qrcode;packages\LVGL-v8.2.0\src\extra\libs\rlottie;packages\LVGL-v8.2.0\src\extra\libs\sjpg;packages\LVGL-v8.2.0\src\extra\others\gridnav;packages\LVGL-v8.2.0\src\extra\others\monkey;packages\LVGL-v8.2.0\src\extra\others\snapshot;packages\LVGL-v8.2.0\src\extra\themes\basic;packages\LVGL-v8.2.0\src\extra\themes\default;packages\LVGL-v8.2.0\src\extra\themes\mono;packages\LVGL-v8.2.0\src\extra\widgets\animimg;packages\LVGL-v8.2.0\src\extra\widgets\calendar;packages\LVGL-v8.2.0\src\extra\widgets\chart;packages\LVGL-v8.2.0\src\extra\widgets\colorwheel;packages\LVGL-v8.2.0\src\extra\widgets\imgbtn;packages\LVGL-v8.2.0\src\extra\widgets\keyboard;packages\LVGL-v8.2.0\src\extra\widgets\led;packages\LVGL-v8.2.0\src\extra\widgets\list;packages\LVGL-v8.2.0\src\extra\widgets\menu;packages\LVGL-v8.2.0\src\extra\widgets\meter;packages\LVGL-v8.2.0\src\extra\widgets\msgbox;packages\LVGL-v8.2.0\src\extra\widgets\span;packages\LVGL-v8.2.0\src\extra\widgets\spinbox;packages\LVGL-v8.2.0\src\extra\widgets\spinner;packages\LVGL-v8.2.0\src\extra\widgets\tabview;packages\LVGL-v8.2.0\src\extra\widgets\tileview;packages\LVGL-v8.2.0\src\extra\widgets\win;applications\lvgl;packages\LVGL-v8.2.0\env_support\rt-thread;packages\netutils-latest\ntp;packages\network_samples-latest;packages\at_device-latest\class\esp32;.\rt-thread\components\dfs\include;.\rt-thread\components\dfs\src;.\rt-thread\components\dfs\filesystems\elmfat;.\packages\at_device-latest\inc;.\applications\lv_desktop_gui\imgs\weather;.\packages\mbedtls-v2.7.10.1\ports\inc;.\packages\mbedtls-v2.7.10.1\mbedtls\include
  memory RVCT1: ROM 0x90000000 size 0x1000000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --keep=bg_lvgl.o
  group Applications
    applications/: lcd_init.c main.c
    ./applications/: guiconf.c
    ./applications/lv_desktop_gui/tests/: albumpageui.c lv_backbtn_test.c lv_imgscreen_page_test.c lvgl_stl.c my_desktop_page_mgt_test.c newspageui.c settingpageui.c weatherpageui.c lv_sun_canvas.c clockpageui.c lv_mycalendar.c
  group AT
    ./rt-thread/components/net/at/src/: at_cli.c at_client.c at_utils.c
    ./rt-thread/components/net/at/at_socket/: at_socket.c
  group at_device
    ./packages/at_device-latest/src/: at_device.c
    ./packages/at_device-latest/class/esp32/: at_socket_esp32.c at_device_esp32.c
    ./packages/at_device-latest/samples/: at_sample_esp32.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c backtrace.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ./rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/ipc/: dataqueue.c ringbuffer.c pipe.c waitqueue.c completion.c workqueue.c ringblk_buf.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    ./rt-thread/components/drivers/rtc/: soft_rtc.c rtc.c
    ./rt-thread/components/drivers/sdio/: sd.c mmc.c block_dev.c sdio.c mmcsd_core.c
    ./rt-thread/components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f469xx.s
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
    ./board/ports/: drv_qspi_flash.c drv_sdcard.c stm32469i_discovery_qspi.c drv_otm8009a.c
    ./board/ports/touch/: drv_touch.c drv_touch_ft.c
    ./libraries/HAL_Drivers/: drv_sdram.c drv_spi.c drv_soft_i2c.c drv_sdio.c drv_qspi.c drv_lcd_mipi.c
  group eziot_components
    packages/ez_iot_os-v2.0.0/components/cJSON/src/: cJSON.c
  group FileSystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ffunicode.c ff.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    rt-thread/src/: device.c clock.c memheap.c scheduler.c components.c mempool.c idle.c ipc.c timer.c irq.c thread.c object.c kservice.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_dma2d.c stm32f4xx_hal_rtc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dsi.c stm32f4xx_hal_i2c.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c
  group LVGL
    packages/LVGL-v8.2.0/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.2.0/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.2.0/src/widgets/: lv_dropdown.c lv_btnmatrix.c lv_img.c lv_slider.c lv_btn.c lv_switch.c lv_canvas.c lv_roller.c lv_line.c lv_objx_templ.c lv_table.c lv_arc.c lv_textarea.c lv_bar.c lv_label.c lv_checkbox.c
    packages/LVGL-v8.2.0/src/font/: lv_font_montserrat_26.c lv_font_montserrat_48.c lv_font_montserrat_32.c lv_font_montserrat_16.c lv_font_montserrat_14.c lv_font_montserrat_36.c lv_font_montserrat_22.c lv_font_fmt_txt.c lv_font_montserrat_46.c lv_font_montserrat_24.c lv_font_montserrat_34.c lv_font_montserrat_20.c lv_font_montserrat_28.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_44.c lv_font_montserrat_28_compressed.c lv_font_montserrat_8.c lv_font_montserrat_42.c lv_font_montserrat_40.c lv_font_simsun_16_cjk.c lv_font_montserrat_18.c lv_font_unscii_16.c lv_font_montserrat_10.c lv_font_montserrat_38.c lv_font_montserrat_30.c lv_font_montserrat_12.c lv_font.c lv_font_montserrat_12_subpx.c lv_font_unscii_8.c lv_font_loader.c
    packages/LVGL-v8.2.0/src/misc/: lv_color.c lv_txt.c lv_lru.c lv_tlsf.c lv_style.c lv_utils.c lv_anim.c lv_ll.c lv_area.c lv_log.c lv_mem.c lv_async.c lv_math.c lv_fs.c lv_printf.c lv_txt_ap.c lv_bidi.c lv_timer.c lv_style_gen.c lv_gc.c lv_anim_timeline.c lv_templ.c
    packages/LVGL-v8.2.0/src/extra/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-v8.2.0/src/core/: lv_disp.c lv_indev_scroll.c lv_obj_style.c lv_indev.c lv_event.c lv_obj_style_gen.c lv_obj.c lv_obj_tree.c lv_obj_class.c lv_obj_pos.c lv_refr.c lv_obj_draw.c lv_obj_scroll.c lv_group.c lv_theme.c
    packages/LVGL-v8.2.0/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.2.0/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.2.0/src/draw/: lv_draw_arc.c lv_draw.c lv_draw_label.c lv_draw_img.c lv_draw_triangle.c lv_draw_line.c lv_draw_mask.c lv_img_decoder.c lv_img_buf.c lv_draw_rect.c lv_img_cache.c
    packages/LVGL-v8.2.0/src/draw/sdl/: lv_draw_sdl_texture_cache.c lv_draw_sdl_mask.c lv_draw_sdl_line.c lv_draw_sdl_polygon.c lv_draw_sdl_bg.c lv_draw_sdl_rect.c lv_draw_sdl_utils.c lv_draw_sdl_stack_blur.c lv_draw_sdl_img.c lv_draw_sdl_arc.c lv_draw_sdl.c lv_draw_sdl_label.c lv_draw_sdl_composite.c
    packages/LVGL-v8.2.0/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.2.0/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.2.0/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.2.0/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-v8.2.0/src/draw/sw/: lv_draw_sw_gradient.c lv_draw_sw_dither.c lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_letter.c lv_draw_sw_img.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_line.c
    packages/LVGL-v8.2.0/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.2.0/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.2.0/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.2.0/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.2.0/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.2.0/src/hal/: lv_hal_tick.c lv_hal_indev.c lv_hal_disp.c
    packages/LVGL-v8.2.0/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.2.0/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.2.0/src/draw/nxp_pxp/: lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c
    packages/LVGL-v8.2.0/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.2.0/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.2.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.2.0/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.2.0/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar_header_arrow.c lv_calendar.c
    packages/LVGL-v8.2.0/src/extra/libs/fsdrv/: lv_fs_posix.c lv_fs_fatfs.c lv_fs_stdio.c lv_fs_win32.c
    packages/LVGL-v8.2.0/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.2.0/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.2.0/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    packages/LVGL-v8.2.0/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.2.0/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.2.0/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.2.0/src/extra/: lv_extra.c
    packages/LVGL-v8.2.0/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.2.0/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.2.0/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.2.0/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.2.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.2.0/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.2.0/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.2.0/src/extra/widgets/keyboard/: lv_keyboard.c
  group LVGL-port
    applications/lvgl/: lv_demo.c lv_port_fs.c lv_port_disp.c lv_port_indev.c lv_desktop_demo.c
    packages/LVGL-v8.2.0/env_support/rt-thread/: lv_rt_thread_port.c
  group NetUtils
    packages/netutils-latest/ntp/: ntp.c
  group network-samples
    packages/network_samples-latest/: httpclient_sample.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev_ipaddr.c netdev.c
    rt-thread/components/net/sal/src/: sal_socket.c
    rt-thread/components/net/sal/impl/: af_inet_at.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/socket/: net_sockets.c net_netdb.c
  group WebClient
    packages/webclient-v2.2.0/samples/: webclient_shard_download_sample.c webclient_post_sample.c webclient_get_sample.c
    packages/webclient-v2.2.0/src/: webclient_file.c webclient.c
  group LV_font
    ./applications/lv_desktop_gui/font/: digitalclock.c HarmonyOS_Sans_SC_Medium.c lv_font_han_sans_bold_number_only_86.c lv_font_han_sans_bold_number_only_114.c m16chinesefont.c MontserratMediumNumber100.c MontserratMediumNumber120.c ui_font_lishu24.c ui_font_lishu16.c ui_font_cnfontgeneral18.c SiYuanRouHeiDengKuanBan120.c
  group LV_img
    ./applications/lv_desktop_gui/imgs/: bg_lvgl.c ui_img_iconimages64_png.c ui_img_iconniews64_png.c ui_img_iconsetting64_png.c ui_img_iconweather64_png.c ui_img_icongame2048_png.c ui_img_seaandsky800_png.c ui_img_testbg_png.c ui_img_iconlocation16_png.c
  group lv_lib
    ./packages/lv_100ask_lib/src/lv_100ask_page_manager/: lv_100ask_page_manager.c
    ./packages/lv_100ask_lib/src/lv_100ask_2048/: lv_100ask_2048.c
    ./packages/lv_100ask_lib/test/lv_100ask_2048_test/: simple_test.c
  group lv_lib_test
    ./packages/LVGL-v8.2.0/examples/assets/: img_cogwheel_argb.c animimg001.c animimg002.c animimg003.c
  group lv_icon_weather
    ./applications/lv_desktop_gui/imgs/weather/: ui_img_baoxue_png.c ui_img_baoyu_png.c ui_img_dabaoyu_png.c ui_img_daxue_png.c ui_img_dayu_png.c ui_img_duoyun_png.c ui_img_leizhenyu_png.c ui_img_leizhenyubingbao_png.c ui_img_qing_png.c ui_img_shachenbao_png.c ui_img_tedabaoyu_png.c ui_img_wu_png.c ui_img_xiaoxue_png.c ui_img_xiaoyu_png.c ui_img_yin_png.c ui_img_yujiaxue_png.c ui_img_zhenxue_png.c ui_img_zhenyu_png.c ui_img_zhongxue_png.c ui_img_zhongyu_png.c
